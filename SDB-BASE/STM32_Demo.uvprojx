# Keil uVision project STM32_Demo.uvprojx, settings and files
target SDB (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SDB_V1^0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,USE_096OLED
  c include: .\CMSIS;.\DRIVER\inc;.\FWLIB\inc;.\USER\inc;.\STARTUP;.\OLED\inc;.\ESP8266\inc;.\UI\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ./STARTUP/: startup_stm32f10x_md.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DRIVER
    ./DRIVER/src/: at24cxx.c beep.c bsp.c delay.c i2c.c ntc.c rrs.c sensor.c spi2.c tim.c usart.c ir.c clock.c dht11.c led.c w25qxx.c spi.c
  group USER
    ./USER/src/: main.c stm32f10x_it.c
  group OLED
    ./OLED/src/: slcd.c
  group ESP8266
    ./ESP8266/src/: esp8266.c
  group UI
    ./UI/src/: ui.c menu.c
